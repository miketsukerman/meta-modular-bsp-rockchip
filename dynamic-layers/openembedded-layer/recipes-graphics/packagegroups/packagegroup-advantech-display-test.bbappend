# libgpiod-tools (gpioset/gpioget) comes from meta-oe, so it is only added
# when meta-oe is part of the build.
RDEPENDS:${PN} += "libgpiod-tools"
